# Repository PrototypeZone/ceng317

File README.md:

# Project Introduction

## Welcome to CENG 317
For weekly activities see the [Critical Path](summer2024criticalpath.md).

## Background
Our focus has been on six areas of ongoing/continuing multi-year work. In these areas, we welcomed brief project charters from industry that proposed the scope, mandate, and contain the system specification (design approach and requirements).

1. Facilities: Bicycle Rental/Parking Lot/Vision System
2. Building Automation: Greenhouse/SolarPanel/Home
3. Consumer: Entertainment Protocol DMX/Baby Monitoring Project
4. Education: Robust Hackable Educational Project
5. Robotics: Control/Navigation/Dashboard
6. Health and Wellness: Wearable 

Currently getting up to speed with the state of the art has been a challenge let alone making a contribution. For example, a modern parking lot will contain vehicle sensors, license plate recognition, RFID/transponders, etc.

Regarding a more accessible project example, there was a time that one would go to a bicycle rental company's shack, provide something of value as a deposit and the person working at the shack would provide a bicycle on the understanding that you would return it along with payment for the amount of time that you used it in exchange for return of your deposit.

Times have changed, now you use your smart phone to provide your credit card information to the bicycle rental company and then you are provided the code to unlock a bicycle and you are charged based on when you next lock it up.

The Computer Engineering Technology capstone consists of creating project similar to this. In this example there is a lock mechanism, a set of buttons to enter a code, lights and sound to provide feedback.

In CENG 317, students learn how to create the embedded modules. In CENG 322, students learn how to write the corresponding app. In CENG 355, the group would package everything up together as a functioning prototype.

- Overall project maximum dimensions of 12 13/16" x 6" x 2 7/8" (32.5cm x 15.25cm x 7.25cm) which represents the space below the tray in the parts kit.
- Project case to be designed for 3D printing/laser cutting.
- Keeping safety and Z462 in mind, the highest AC voltage that is to be used is 16Vrms from a wall adapter from which +/- 15V or as high as 45 VDC can be obtained. Maximum power consumption is to be 20 Watts.
- We work with prototypes and prototypes are not to be left powered unattended.

## Project Examples
- Automated plant watering system: modular [scaleable](https://www.verticalgardensdirect.com.au/collections/best-sellers/products/maze-vertical-planter-kit) [irrigated](https://www.irrigationdepot.ca/boutique/english/product/item/living-wall-vertical-garden-glw08.html) planters.
- Parking lot
- Living environment monitoring system
- Pet food dispenser
- Aquarium monitor
- Wellness monitor
- Envirorover which measures temperature, humidity, and light as it moves
- Waste bin monitoring system
- Sailing race start signal system as per [page 41](https://www.nsyc.net/wp-content/uploads/RC_SEMINAR_NSYC.pdf)   
    - [Drawing](https://buckeyelakeyc.com/wp-content/uploads/2020/02/RC_Drawing.png), [Actual](http://www.sail.ie/speedtips/speedtips_images/favour18.jpg)
    - -6 *Attention Signal* 4 Horns
    - -5 *Warning Signal* Red Shape up, Horn 
    - -4 *Preparatory Signal* P Flag Up, Horn 
    - -1 *One to go warning* P Flag Down, Long Horn 
    - 0 *Start* Red Shape down, Horn
    - If there is a false start X flag up as per [page 50](https://www.nsyc.net/wp-content/uploads/RC_SEMINAR_NSYC.pdf)
- Autonomous Electric Skidsteer
- IoT Home Appliance
- Traffic light
- Traffic counter
- Scale model automation [Little Canada](https://little-canada.ca/), [bicycle](https://www.youtube.com/watch?v=ieiawg7offE)   
- Vending Machine
- Book/Equipment Sign-out System
- Depending on how CENG 260 goes: https://github.com/alexa/avs-device-sdk, https://www.mashgin.com/product/mashgin-kiosk
- Air monitoring
- Next bus sign
- Touchfree washroom
- Solar battery charger
- Water bottle filling station
- [Elevator](https://hackaday.com/2021/02/04/reverse-engineering-an-elevator-control-panel-results-in-clicky-goodness/)
- [Prescription Kiosk](https://humber.ca/staff/announcement/spotrx-pharmacy-now-available-north-campus)
- Fire protection system
- Golf simulator
- Trainable robot arm   

## Your Existing Sense Hat
In addition to power and ground the sense hat uses:   
pin 3 -- GPIO2 or SDA   
pin 5 -- GPIO3 or SCL   
pin 16 -- GPIO23 (IMU Interrupt)   
pin 18 -- GPIO24 (IMU Interrupt)   
pin 22 -- GPIO25 (Atmel Prog Reset)   
pin 24 -- GPIO8 (Atmel Chip Reset)   
pin 27 -- GPIO0 (or maybe ID_SD or maybe EEPROM SDA or maybe HAT ID)   
pin 28 -- GPIO1 (or maybe ID_SC or maybe EEPROM SCL or maybe HAT ID)   
LED2472G and navigation pad connected via an Atmel ATTINY88 (0x46)   
LSM9DS1 IMU magnetometer 0x1c(0x1e) and accelerometer/gyroscope 0x6a(0x6b)   
[9DoF Stick IMU - LSM9DS1 SparkFun Retired Product equivalent to that on the sense hat](https://www.sparkfun.com/products/13944)   
LPS25H Pressure/Temperature sensor (0x5c)   
HTS221 Humidity/Temperature sensor (0x5f)   
Version 2 also has TCS3400 RGB colour sensor (0x39)   

## Your individual project in CENG 317
- Each student will choose at least one [additional sensor/effector](sensorseffectors.md)
   
- Each student creates a custom interface board to fit between their Sense Hat and their Broadcom Single board computer to connect their chosen additional sensor or effector to their Raspberry Pi. A case should be lasercut/3D printed to accomodate their boards, sensor, and computing device within the overall maximum project dimensions.
   
- Standoffs, screws to be specified on [Bill Of Materials](hardware/bom.md)   
- Although it is not always the situation, if all the students in a group formed in CENG 322 software project are also in the same section in CENG 317 hardware project, the students may combine their designs into one PCB design of which multiple are made. This is also an opportunity to ensure that code written can operate with multi threading.
- Ideally the PCB would comply with the [Raspberry Pi Hardware Attached on Top specifications](https://github.com/raspberrypi/hats) including an [EEPROM](https://www.digikey.ca/en/products/base-product/onsemi/488/CAT24C256/56536) but the Raspberry Pi only checks I2C address 0x50 for eeproms so currently it is not designed for stacking hats.
- It will include a [Stacking Header](https://www.digikey.com/en/products/detail/adafruit-industries-llc/1979/6238003).
- It will include a [Grove socket](https://www.digikey.ca/en/products/detail/seeed-technology-co-ltd/110990037/5482561) to make use of a [Grove Cable](https://www.digikey.ca/en/products/detail/adafruit-industries-llc/4528/11627737).
- Use [KiCad](https://github.com/PrototypeZone/ceng317/tree/main/hardware/pcb) for the design.
- We also add: a spare header, a 2N4124 NPN transistor with a 2.2 kOhm resistor between pin 11 -- GPIO17 and the base of the transistor, connect the emitter to the ground, and connect an LED with a series 220 Ohm resistor on the collector side to 3.3V.

## KiCad design hardware/pcb/StudentName2023-11-08.kicad_pcb

File hardware/pcb/README.md:

# KiCad   
1. We will be designing a Raspberry Pi Interface board using [KiCad 6.0.10](https://downloads.kicad.org/kicad/windows/explore/stable/download/kicad-6.0.10-x86_64.exe).
2. Chapter 18 of the below textbook on pages 259-284, pages 268-293 of the pdf, has Project 2: Design a small Raspberry Pi HAT.
   Dalmaris, Peter. (2018). KiCad Like a Pro 2nd edition. United Kingdom: Elektor International Media B.V. Tech Explorations: EBOOK SOLO 978-1-64440-886-5. Note that newer versions of the textbook do not include the Design a small Raspberry Pi HAT project.   
3. Launch KiCad:   

4. Start with default settings:   

5. I have followed [Using a template](https://techexplorations.com/guides/kicad/3e/create-a-new-kicad-project-from-a-template/) and [Vlad's guide to PCB facilities in J233](PCBPrototypes.md) to a certain extent in order to create the below files to start from:
-   [Project File](/hardware/pcb/StudentName2023-11-08.kicad_pro)
-   [Schematic File](/hardware/pcb/StudentName2023-11-08.kicad_sch)
-   [PCB File](/hardware/pcb/StudentName2023-11-08.kicad_pcb)   
6. Download the above /hardware/pcb/StudentName2023-11-08.kicad_pro, pcb, and sch.
7. Use KiCad to open the _pro project file, then navigate to opening the PCB file.
8. Change the board in the PCB view to have your name and the current date.
9. If not routed already, route the BJT as a switch circuit (Section 4.5 Page 192 in your Electronic Devices by Floyd) traces on the PCB. To do this:
   - Click on the the end of say a resistor and press 'x' on the keyboard.
   - Then click on the other terminal that it should be connected to.
   - Consider ease of soldering.
10. Save "project as" what you changed the name and date to.   
11. Use File->fabrication outputs->Gerbers (.gbr)... to Plot the Gerbers   
12. also "Generate Drill Files"->PTH and NPTH in single file   
13. Save project
14. Use the Gerber Viewer to preview:
    1. F_Cu.gtl
    2. B_Cu.gbl
    3. F_Silkscreen.gto
    4. B_Silkscreen.gbo
    5. F_Mask.gts
    6. B_Mask.gbs
    7. Edge_Cuts.gm1
    8. .drl    
15. Upload your work in a zip file to your /hardware/pcb/ folder in the PrototypeZone organisation. The name of the zip should be in the format of your changed name and date (StudentName2023-09-24.zip) and it should contain the 3 KiCad files you worked on, the combined drill file, and the default Gerber plots as per the following list:   
    1. F.Cu   
    2. B.Cu   
    3. F.Silkscreen   
    4. B.Silkscreen   
    5. F.Mask   
    6. B.Mask   
    7. Edge.Cuts   
    8. The drill file   
    9. Your _pro file   
    10. Your _sch file   
    11. Your _pcb file
16. Once the professor knows that your zip file has been uploaded correctly they will send the class set to the lab next door to be made [in house](/hardware/pcb/PCBPrototypes.md).
17. When the completed PCB is available, proceed to [inspect it](/hardware/pcb/inspection.md).
18. Further iterations of the board can be made [in house](/hardware/pcb/PCBPrototypes.md) or by [OSHpark](https://oshpark.com/),  [MicroArt](https://microart.pcborders.com/), [Bittele](https://onlinequote.7pcb.com/), [JLC](https://jlcpcb.com/), [PCBway](https://www.pcbway.com/QuickOrderOnline.aspx), [Seeedstudio](https://www.seeedstudio.com/fusion_pcb.html), or other alternatives.

Parts:
D1: LED; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm
J1: GPIO; PinSocket_2x20_P2.54mm_Vertical
J2: Qwiic Right Angle; PinSocket_1x04_P2.00mm_Horizontal
J3: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Horizontal
Q1: 2N4124; TO-92_Inline_Wide
R1: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R2: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal

Connections:
+3V3: J1.1, J2.2, J3.2, R2.1
+5V: J1.2
/3.3V17: J1.17
/5V4: J1.4
/GND6: J1.6
/GND14: J1.14
/GND20: J1.20
/GND25: J1.25
/GND30: J1.30
/GND34: J1.34
/GND39: J1.39
/GPIO2/SDA1: J1.3, J2.3, J3.3
/GPIO3/SCL1: J1.5, J2.4, J3.4
/GPIO4/GPCLK0: J1.7
/GPIO5: J1.29
/GPIO6: J1.31
/GPIO7/SPI0.CE1: J1.26
/GPIO8/SPI0.CE0: J1.24
/GPIO9/SPI0.MISO: J1.21
/GPIO10/SPI0.MOSI: J1.19
/GPIO11/SPI0.SCLK: J1.23
/GPIO12/PWM0: J1.32
/GPIO13/PWM1: J1.33
/GPIO14/TXD0: J1.8
/GPIO15/RXD0: J1.10
/GPIO16: J1.36
/GPIO17: J1.11, R1.1
/GPIO18/PCM.CLK: J1.12
/GPIO19/PCM.FS: J1.35
/GPIO20/PCM.DIN: J1.38
/GPIO21/PCM.DOUT: J1.40
/GPIO22: J1.15
/GPIO23: J1.16
/GPIO24: J1.18
/GPIO25: J1.22
/GPIO26: J1.37
/GPIO27: J1.13
/ID_SCL: J1.28
/ID_SDA: J1.27
GND: J1.9, J2.1, J3.1, Q1.1 (E)
unnamed: D1.1 (K), Q1.3 (C)
unnamed: D1.2 (A), R2.2
unnamed: Q1.2 (B), R1.2

Notes on the sheet:
Additional pin functions: https://pinout.xyz/

Board: 2 copper layers, 65.0 x 56.0 mm, 11 parts (1 on the bottom side), 8 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_2.7mm_M2.5

## Commit log

2023-09-25 Laser example update
2023-10-02 added sensor bom.md
2023-10-13 Rename winter2023criticalpath.md to winter2023criticalpath355.md
2023-11-09 Illustrator
2023-11-16 3mm fix
2023-11-16 Added Student Name
2023-11-22 Preparing for next semester
2023-11-24 Transition to Illustrator
2023-11-28 Removal of duplicated cut lines
2024-01-05 Updating for summer
2024-01-05 Update for summer
2024-01-05 Inspection update
2024-01-06 Consolidating capstone files
